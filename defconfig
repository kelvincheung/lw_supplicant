## defconfig
```kconfig
#CONFIG_CROSS_COMPILE=arm-linux-
CONFIG_OS_NO_C_LIB=y
CONFIG_INTERNAL_MD5=y
CONFIG_INTERNAL_SHA1=y
```
